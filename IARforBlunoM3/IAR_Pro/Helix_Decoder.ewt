<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\startup_stm32f10x_hd.s</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\..\driver\stm\df_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\stm\df_i2s.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\stm\df_usart1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\senor\sd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\stm\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\driver\senor\wm8978\wm8978.c</name>
    </file>
  </group>
  <group>
    <name>library</name>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\STM32F10x_StdPeriph_Driver\src\stm32f10x_usart.c</name>
    </file>
  </group>
  <group>
    <name>Plus</name>
    <file>
      <name>$PROJ_DIR$\..\user\fputc_dump.c</name>
    </file>
  </group>
  <group>
    <name>Third-Party Library</name>
    <group>
      <name>Fat32</name>
      <file>
        <name>$PROJ_DIR$\..\library\fat32\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\fat32\ff.c</name>
      </file>
    </group>
    <group>
      <name>Helix_Decoder</name>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\arm\asmmisc.S</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\arm\asmpoly_thumb2.S</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\bitstream.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\buffers.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\dct32.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\dequant.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\dqchan.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\huffman.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\hufftabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\imdct.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\mp3dec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\mp3tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\scalfact.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\stproc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\subband.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\library\helix_mp3\codec\fixpt\real\trigtabs_fixpt.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>user</name>
    <file>
      <name>$PROJ_DIR$\..\user\common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user\system_stm32f10x.c</name>
    </file>
  </group>
  <group>
    <name>Utility</name>
    <file>
      <name>$PROJ_DIR$\..\utility\mp3\audioplay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\utility\mp3\df_mp3play.c</name>
    </file>
  </group>
</project>


