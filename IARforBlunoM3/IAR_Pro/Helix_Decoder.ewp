# IAR project Helix_Decoder.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; ARM_ADS; __CW32__
  ICCARM.CCIncludePath2: ..\STM32F10x_StdPeriph_Driver\inc; ..\user\include; ..\CMSIS\CM3\CoreSupport; ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\library\helix_mp3\codec\fixpt\real; ..\library\helix_mp3\codec\fixpt\pub; ..\utility\mp3\include; ..\driver\include; ..\library\fat32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Helix_Decoder.bin
  ILINK.IlinkOutputFile: Helix_Decoder.out
  ILINK.IlinkIcfFile: Helix_Decoder.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group Driver
    ../driver/stm/: df_usart1.c spi.c
    ../driver/senor/: sd.c
  group library
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Plus
    ../user/: fputc_dump.c
  group Third-Party Library/ARM_Platform
    ../library/helix_mp3/codec/fixpt/real/arm/: asmmisc_rvds.s
  group Third-Party Library/Fat32
    ../library/fat32/: diskio.c ff.c
  group Third-Party Library/Helix_Decoder
    ../library/helix_mp3/codec/fixpt/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
    ../library/helix_mp3/codec/fixpt/: mp3dec.c mp3tabs.c
  group user
    ../user/: common.c main.c stm32f10x_it.c system_stm32f10x.c
  group Utility
    ../utility/mp3/: df_mp3play.c
